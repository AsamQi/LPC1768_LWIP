# Keil uVision project CMSIS_Example_LPC17xx.uvproj, settings and files
target Simulator (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: CMSIS_Example
  c flags: Optim=1
  c include: ../../../CoreSupport; ../../../DeviceSupport/NXP/LPC17xx
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group CMSIS files
    ../../../CoreSupport/: core_cm3.c
    ./: startup_LPC17xx.s system_LPC17xx.c
  group Source files
    ./: main_LPC17xx.c
  group Documentation
    ./: Abstract.txt
target MCB1700 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: CMSIS_Example
  c flags: Optim=1
  c include: ../../../CoreSupport; ../../../DeviceSupport/NXP/LPC17xx
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
